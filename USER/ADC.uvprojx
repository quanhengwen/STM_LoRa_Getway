# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_SX1276_RADIO
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\radio;..\sx12xxEiger;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group SYSTEM
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/KEY/: key.c
    ./: PVD.c flash.c
    ../HARDWARE/SPI/: spi.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/sx1278/: sx1278.c
  group FWLib
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
    ./: system_stm32f10x.c stm32f10x_it.c
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_dac.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_spi.c
  group radio
    ../radio/: radio.c sx1276.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group sx1278
    ../sx12xxEiger/: sx12xxEiger.c sx1276-Hal.c
